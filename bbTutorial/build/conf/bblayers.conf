## bbTutorial/build/conf/bblayers.conf
```bitbake
BBPATH := "${TOPDIR}"
BBFILES ?= ""
BBLAYERS = "/home/roelof/devel/linuxluna/bbTutorial/meta-tutorial"
```
