DESCRIPTION = "I am the first recipe"
PR = "r1"
do_build () {
  touch ~/lunix-rocks
}
